# Keil uVision project lcd3in5-demo.uvprojx, settings and files
target lcd3in5-demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lcd3in5-demo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;     ../Drivers/STM32F1xx_HAL_Driver/Inc;     ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;     ../Drivers/CMSIS/Include;     ..\User\Fonts;     ..\User\FATFS;     ..\User\Config;     ..\User\LCD;     ..\User\Lib;     ..\User\SDCard
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: spi.c usart.c stm32f1xx_hal_msp.c main.c gpio.c stm32f1xx_it.c tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_spi.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Fonts
    ../User/Fonts/: font8.c font12.c font16.c font20.c font24.c
  group FATFS
    ../User/FATFS/: diskio.c fatfs_storage.c ff.c
  group LCD
    ../User/LCD/: LCD_Bmp.c LCD_Driver.c LCD_GUI.c LCD_Touch.c
  group SDcard
    ../User/SDCard/: MMC_SD.c
  group DEV_Config
    ../User/Config/: DEV_Config.c
software components: CMSIS:CORE 4.1.0
